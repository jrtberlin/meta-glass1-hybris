RDEPENDS_${PN}_append_glass1 = " ngfd-plugin-droid-vibrator "
