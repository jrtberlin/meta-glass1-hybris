RDEPENDS_${PN}_append_glass1 = " qt5-qpa-hwcomposer-plugin "
