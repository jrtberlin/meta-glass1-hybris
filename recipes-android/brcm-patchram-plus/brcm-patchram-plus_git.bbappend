FILESEXTRAPATHS_prepend_glass1 := "${THISDIR}/brcm-patchram-plus:"
SRC_URI_append_glass1 = " file://patchram.service "
