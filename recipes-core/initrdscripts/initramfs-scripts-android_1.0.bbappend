FILESEXTRAPATHS_prepend_glass1 := "${THISDIR}/${PN}:"
COMPATIBLE_MACHINE_glass1 = "glass1"
